## boards/shields/nice_view_horizontal/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_HORIZONTAL
    def_bool $(shields_list_contains,nice_view_horizontal)
```
